# Keil uVision project Tick-Timer.uvprojx, settings and files
target GPIO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO-Output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;..\..\FreeRTOS-STM32-HAL-Examples\FreeRTOS-Source\include;..\..\FreeRTOS-STM32-HAL-Examples\FreeRTOS-Source\portable\RVDS\ARM_CM4F;..\RTOS-Test
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
    ../../FreeRTOS-STM32-HAL-Examples/FreeRTOS-Source/: list.c tasks.c
    ../../FreeRTOS-STM32-HAL-Examples/FreeRTOS-Source/portable/MemMang/: heap_2.c
    ../../FreeRTOS-STM32-HAL-Examples/FreeRTOS-Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
