# Keil uVision project Simple-Tasks.uvprojx, settings and files
target Simple-Tasks (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Simple-Tasks
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\FreeRTOS-HAL-Simple-Tasks;.\include;..\FreeRTOS-Source\include;..\FreeRTOS-Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --show_parent_lib --show_full_path
  group Source
    ./Source/: stm32f4xx_it.c main.c
  group FreeRTOS
    ../FreeRTOS-Source/: list.c tasks.c
    ../FreeRTOS-Source/portable/MemMang/: heap_2.c
    ../FreeRTOS-Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.7.3, Device:STM32Cube HAL:Common 1.7.3, Device:STM32Cube HAL:Cortex 1.7.3, Device:STM32Cube HAL:DMA 1.7.3, Device:STM32Cube HAL:Flash 1.7.3, Device:STM32Cube HAL:GPIO 1.7.3, Device:STM32Cube HAL:PWR 1.7.3, Device:STM32Cube HAL:RCC 1.7.3, Device:STM32Cube HAL:TIM 1.7.3, Device:Startup 2.6.2
